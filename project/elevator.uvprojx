# Keil uVision project elevator.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: elevator
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c usart.c cli.c cli.h usart.h
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Coroutines 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Message Buffer 10.4.6, RTOS:Stream Buffer 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Device:Startup 1.0.0
